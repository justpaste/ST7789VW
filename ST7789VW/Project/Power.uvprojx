# Keil uVision project Power.uvprojx, settings and files
target Power (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Power +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030
  c include: ..\Libraries\CMSIS\Device\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: main.c stm32f0xx_it.c delay.c sys.c usart1.c adc.c tim3.c cs1237.c w25qxx.c spi.c Fonts.c oled.c
  group Libraries
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_misc.c stm32f0xx_dma.c stm32f0xx_tim.c stm32f0xx_spi.c
  group CMSIS
    ../Libraries/CMSIS/Device/Source/: system_stm32f0xx.c
  group Startup
    ../Libraries/CMSIS/Device/Source/arm/: startup_stm32f030.s
  group Doc
    ../Doc/: 说明.txt
